# Keil uVision project SH30F9xxx.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SH30F9071 Sinowealth
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0000000-0x003FFFF) CLOCK(4000000~48000000) CPUTYPE("Cortex-M0+")
  output: SH30F9xxx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Source\Inc;..\Source\User;..\Source\bsp;..\Source\Libraries\CMSIS\Device\Include;..\Source\Libraries\SH30F9xx_sb0_StdPeriph_Driver\inc;..\Source\Libraries\CMSIS\Include;..\Source\drv;..\Source\fsm;..\Source\mdl;..\Source\lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Source/Libraries/CMSIS/Device/Source/: system_sh30f9xx_sb0.c
    ../Source/Libraries/CMSIS/Device/Source/Startup/: startup_sh30f9xx_sb0_keil.s
  group User
    ../Source/User/: main.c
    ../Source/user/: sh30f9xx_sb0_interrupt.c Task.c user_Comm.c user_DCFan.c user_systemRun.c user_TmpCtrl.c user_MachineInfo.c user_temper.c user_SegCtrl.c user_debug.c user_washMode.c user_Function.c user_Pump.c user_adaptive.c CompileSetting.h filter.c
  group Bsp
    ../Source/bsp/: bsp.h bsp_adc.c bsp_exit.c bsp_gpio.c bsp_iwdt.c bsp_lvr.c bsp_nvic.c bsp_pca.c bsp_pwm.c bsp_systick.c bsp_tim.c bsp_uart0.c bsp_uart1.c bsp_uart2.c bsp_uart3.c bsp_eeprom.c bsp_uart5.c
  group StdPeriph_Driver
    ../Source/Libraries/SH30F9xx_sb0_StdPeriph_Driver/src/: sh30f9xx_sb0_adc.c sh30f9xx_sb0_crc.c sh30f9xx_sb0_exti.c sh30f9xx_sb0_fifo.c sh30f9xx_sb0_flash.c sh30f9xx_sb0_gpio.c sh30f9xx_sb0_hwdt.c sh30f9xx_sb0_nvic.c sh30f9xx_sb0_pca.c sh30f9xx_sb0_pwm.c sh30f9xx_sb0_rcc.c sh30f9xx_sb0_spi.c sh30f9xx_sb0_syscfg.c sh30f9xx_sb0_timer.c sh30f9xx_sb0_twi.c sh30f9xx_sb0_uart.c sh30f9xx_sb0_wwdt.c
  group Drv
    ../Source/drv/: drv_InOutPut.c SoftwareI2C.c drv_DCFan.c drv_Pump.c
  group Mdl
    ../Source/mdl/: FIFO.c mdl_adc.c mdl_GetWave.c mdl_usart.c mdl_Valve.c mdl_BLF.c mdl_flash.c mdl_DS1302.c mdl_filter.c
    ../Source/drv/: SPL06_01.c
  group Fsm
    ../Source/fsm/: fsm.c fsm_endClean.c fsm_error.c fsm_idle.c fsm_igintion.c fsm_init.c fsm_preFan.c fsm_stable.c fsm_debug.c fsm_F6.c fsm_E0.c
  group Lib
    ../Source/lib/: WJL_RSQ_Ai_V1.c
